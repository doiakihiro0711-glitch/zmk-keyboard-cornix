## boards/shields/cornix_prospector/Kconfig.shield
```kconfig
config SHIELD_CORNIX_PROSPECTOR
    def_bool $(shields_list_contains,cornix_prospector)
```
